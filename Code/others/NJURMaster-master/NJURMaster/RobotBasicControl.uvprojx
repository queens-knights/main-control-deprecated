# Keil uVision project RobotBasicControl.uvprojx, settings and files
target RobotBasicControl (ARM-ADS)
  device: STM32F427II STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RobotBasicControl
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F427XXX,__FPU_PRESENT=1,__FPU_USED=1,ARM_MATH_CM4,__CC_ARM
  c include: .\libraries\STLibraries;.\users;.\drivers;.\applications;.\math
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group users
    ./users/: main.c stm32f4xx_it.c stm32f4xx_conf.h stm32f4xx_it.h startup_stm32f427_437xx.s main.h sys_config.h
  group drivers
    ./drivers/: bsp_flash.c can.c driver.c laser.c led.c pwm.c rc.c timer.c usart2.c usart3.c usart6.c encoder.c spi.c mpu6500.c ist8310.c
  group applications
    ./applications/: protocol.c modeduty.c datatransfer.c dutytasks.c selfcheck.c controltask.c cantask.c appinit.c parameters.c imu.c
  group libs
    ./libraries/STLibraries/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c system_stm32f4xx.c
  group math
    ./math/: filter.c mymath.c pid.c ramp.c
